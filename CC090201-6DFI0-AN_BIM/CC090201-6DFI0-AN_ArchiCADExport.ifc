Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-08-16T11:35:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.90.15 - Exporter 21.1.90.15 - Alternate UI 21.1.90.15
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 16 11:35:32 2024 * Host: DCreative * Database: C:\Users\chatp\AppData\Local\Temp\a7319c8a-42fe-483d-a27f-5cb0d059d5e9\0b4ed4bc-4ca5-4f01-a662-17bacfc68cd5\ifc * Database version: 5507 * Database creation date: Fri Aug 16 11:35:30 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 16 11:35:31 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 16 11:35:31 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
Port_347976 | SINK
Port_347976 | SOURCE

# IfcFlowTerminal: CC090203-6DFP0-AN_REVIT:S200 OP Touchless toilet (PHL), CC090203-6DFP0-AN_REVIT:S200 OP Touchless toilet (PHL):347976
In: Level 1
Type - Material: White
Type - Pset_ManufacturerTypeInformation - Manufacturer: INAX
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: S200 OP Touchless toilet (PHL)
Material: White, Chrome
Pset_DistributionFlowElementCommon - Reference: S200 OP Touchless toilet (PHL); sets with these values: 2
